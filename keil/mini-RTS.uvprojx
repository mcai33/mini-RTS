# Keil uVision project mini-RTS.uvprojx, settings and files
target mini-RTS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC123LD4AN0 Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.2
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x11000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: mini-RTS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST=1
  c include: ..\app\inc;..\drv\inc;..\fml\inc;..\hal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: main.c sch.c
  group drv
    ../drv/: drv_74hc595.c drv_common.c drv_sch.c drv_led.c drv_ds1302.c drv_nuc123.c descriptors.c hid_transfer.c
  group bsp
    ../soc/ARM-Cortex-M0/Nuvoton/NUC123BSP/src/: adc.c clk.c crc.c fmc.c gpio.c i2c.c i2s.c pdma.c ps2.c pwm.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
software components: CMSIS:CORE 5.1.2, Device:Startup 0.00.001
