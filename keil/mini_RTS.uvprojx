# Keil uVision project mini_RTS.uvprojx, settings and files
target PCBA_Test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC123LD4AN0 Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.2
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x11000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: mini-RTS +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST=1
  c include: ..\app\inc;..\drv\inc;..\soc\ARM-Cortex-M0\Nuvoton\NUC123BSP\inc;..\soc\ARM-Cortex-M0\Nuvoton\NUC123BSP\CMSIS\inc;..\fml\inc;..\hal\inc;..\soc\ARM-Cortex-M0\Nuvoton\NUC123BSP;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
  group app
    ../app/: main.c sch.c module_a.c module_b.c shared_state.c
  group drv
    ../drv/: drv_74hc595.c drv_common.c drv_sch.c drv_led.c drv_ds1302.c
  group bsp
    ../soc/ARM-Cortex-M0/Nuvoton/NUC123BSP/: startup_NUC123.s system_NUC123.c
    ../soc/ARM-Cortex-M0/Nuvoton/NUC123BSP/src/: adc.c clk.c crc.c fmc.c gpio.c i2c.c i2s.c pdma.c ps2.c pwm.c retarget.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
